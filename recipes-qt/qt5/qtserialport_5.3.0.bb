require qt5-5.3.0.inc
require ${PN}.inc

SRCREV = "360767286dfc77a08ac28bf03f35b289fd37536d"

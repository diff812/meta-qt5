require qt5-5.3.0.inc
require ${PN}.inc

SRCREV = "5f0fbc683bce200b17fea82eb711d8ad4c2f3f23"

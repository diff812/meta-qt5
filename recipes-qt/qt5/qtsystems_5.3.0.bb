require qt5-5.3.0.inc
require ${PN}.inc

SRCREV = "aa651c73bf7bc57c1b6b1bfcfa9afe901884a102"

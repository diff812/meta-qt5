require qt5-5.3.0.inc
require ${PN}.inc
QT_MODULE_BRANCH = "5.3.0"

SRCREV = "251a3c50ca89c32678fb51de48124d144155f704"

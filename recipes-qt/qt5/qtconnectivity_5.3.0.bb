require qt5-5.3.0.inc
require ${BPN}.inc

SRCREV = "7f339a2dde95e8720149f022e86f553692515a5f"

require qt5-5.3.0.inc
require ${PN}.inc

SRCREV = "c866dd6139bde855a0bc8cd8a0479601dd33178b"
